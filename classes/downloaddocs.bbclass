python __anonymous__ () {
  bb.note("meta-gateway: stub downloaddocs.bbclass loaded (no operation).")
}